require recipes-support/uhd/uhd.inc

LIC_FILES_CHKSUM = "file://LICENSE;md5=8255adf1069294c928e0e18b01a16282"

SRC_URI = "http://files.ettus.com/binaries/uhd/uhd_003.008.000-release/uhd-${PV}.tar.gz"

SRC_URI[md5sum] = "807a4d895c976575e3140d21c7234510"
SRC_URI[sha256sum] = "ceaf7be512a30ce924955f9f5a6135796100d2377ae5526ada6b6e4ae0c368f3"

