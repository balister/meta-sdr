require libbladerf.inc

SRCREV = "e67ea0ea4092cf67d232f09e261f374db6a4599e"
