require bladerf-fpga.inc

SRC_URI[x40.md5sum] = "bf7016f5cbe657df8d25ce12bc48c3aa"
SRC_URI[x40.sha256sum] = "48852d9d0a64f03331e0c3c1adf6dd56ee8ef77bf6ae93401bf845a1117714a8"

SRC_URI[x115.md5sum] = "29676f895788c23339b4fee85684b623"
SRC_URI[x115.sha256sum] = "112b315efaa4aef4bdb15285fb637ff1c93aa24cc3aa98d86ebb4e02d2352aa6"

