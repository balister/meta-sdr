INSANE_SKIP_${PN} += "already-stripped"
