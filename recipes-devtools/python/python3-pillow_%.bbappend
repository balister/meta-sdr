BBCLASSEXTEND = "native"
RDEPENDS_${PN}_class-native = ""
