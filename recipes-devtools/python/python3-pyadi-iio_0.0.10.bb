require python3-pyadi-iio.inc
inherit pypi setuptools3
